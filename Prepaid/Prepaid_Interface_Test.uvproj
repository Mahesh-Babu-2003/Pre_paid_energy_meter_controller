# Keil uVision project Prepaid_Interface_Test.uvproj, settings and files
target PREPAY_V0_Interface_Test (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PREPAY_V0_Interface_Test +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\src;vendor\MS51_BSP\MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE\Library\Device\Include;vendor\MS51_BSP\MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Interface Test
    ./src/: main.c interface_test.c interface_test.h board_io.c board_io.h lcd_595.c lcd_595.h i2c_probe.c i2c_probe.h rs485_test.c rs485_test.h
  group Nuvoton BSP Drivers
    vendor/MS51_BSP/MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE/Library/StdDriver/src/: common.c sys.c uart.c delay.c
  group Startup
    vendor/MS51_BSP/MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE/Library/Startup/KEIL/: STARTUP.A51
